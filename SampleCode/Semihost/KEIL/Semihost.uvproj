# Keil uVision project Semihost.uvproj, settings and files
target Semihost (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    ../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c
  group User
    ../: main.c README.txt
