# Keil uVision project Hard_Fault_Sample.uvproj, settings and files
target Hard_Fault_Sample (6160000::V6.16::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Hard_Fault_Sample
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    ../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
  group User
    ../: main.c
