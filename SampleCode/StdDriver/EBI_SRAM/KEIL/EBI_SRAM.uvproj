# Keil uVision project EBI_SRAM.uvproj, settings and files
target EBI_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: EBI_SRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c ebi_sram.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c ebi.c
