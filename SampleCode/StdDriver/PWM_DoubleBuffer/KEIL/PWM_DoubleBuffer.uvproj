# Keil uVision project PWM_DoubleBuffer.uvproj, settings and files
target PWM_DoubleBuffer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: PWM_DoubleBuffer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\..\..\..\libM051Series\CMSIS\CM0\CoreSupport;..\..\..\..\libM051Series\StdDriver\inc;..\..\..\..\LibM051Series\M051-LB_004_Driver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c pwm.c retarget.c sys.c uart.c clk.c
