# Keil uVision project FMC_IAP.uvproj, settings and files
target FMC_IAP (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_IAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c LoaderImage.s main_LD.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_IAP_LD (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_IAP_LD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  link misc: as above
