# Keil uVision project FMC_MultiBoot_SwReset.uvproj, settings and files
target FMC_MultiBoot (6190000::V6.19::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_MultiBoot_SwReset
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOOT = -1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_Boot0 (6190000::V6.19::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=5
  c define: BOOT = 0
  c include: as above
  library: MicroLIB
  link misc: as above
target FMC_Boot1 (6190000::V6.19::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=5
  c define: BOOT = 1
  c include: as above
  library: MicroLIB
  link misc: as above
target FMC_Boot2 (6190000::V6.19::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=5
  c define: BOOT = 0
  c include: as above
  library: MicroLIB
  link misc: as above
target FMC_Boot3 (6190000::V6.19::ARMCLANG)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_Boot3
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5
  c define: BOOT = 0
  c include: as above
  library: MicroLIB
  link misc: as above
