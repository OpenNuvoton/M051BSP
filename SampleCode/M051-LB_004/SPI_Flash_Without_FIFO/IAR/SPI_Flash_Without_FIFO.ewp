# IAR project SPI_Flash_Without_FIFO.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\M051-LB_004\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Flash_Without_FIFO.bin
  ILINK.IlinkOutputFile: SPI_Flash_Without_FIFO.out
  ILINK.IlinkIcfFile: SPI_Flash_Without_FIFO.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/M051-LB_004/src/: Ascii_Table.C lcd_driver.c spi_flash_without_fifo.c
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c uart.c
  group User
    ../: main.c
