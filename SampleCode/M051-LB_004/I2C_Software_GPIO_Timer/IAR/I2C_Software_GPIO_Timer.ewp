# IAR project I2C_Software_GPIO_Timer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\M051-LB_004\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Software_GPIO_Timer.bin
  ILINK.IlinkOutputFile: I2C_Software_GPIO_Timer.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
    ../../../../Library/M051-LB_004/src/: I2C_Software_GPIO_with_Timer.c
  group User
    ../: main.c
