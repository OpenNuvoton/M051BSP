# Keil uVision project I2C_Software_GPIO_Timer.uvproj, settings and files
target I2C_Software_GPIO_Timer (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I2C_Software_GPIO_Timer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\M051-LB_004\inc
  library: MicroLIB
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c gpio.c
    ../../../../Library/M051-LB_004/src/: I2C_Software_GPIO_with_Timer.c
